# Allegro board lp-em-cc1354p10-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DIO35: length 25.9
  TOP w0.15: v1(30.61,49.53) 30.61,49.46 30.75,49.32 U1.11 ; v1(33.22,48.96) 33.41,48.96 33.7,49.25 34.38,49.25 34.48,49.15 35.61,49.15 35.63,49.12 35.99,49.12 36.06,49.2 R18.2
  L3 w0.15: P5.2 48.26,40.76 47.7,41.32 47.22,41.32 40.87,47.68 38.32,47.68 37.88,48.12 35.38,48.12 34.66,48.84 34.66,48.84 34.41,49.09 34.41,49.09 34.3,49.2 33.46,49.2 v1(33.22,48.96)
  BOTTOM w0.15: v1(30.61,49.53) 31.18,48.96 v1(33.22,48.96)
DIO35_RF_SUB1G: length 19.5
  TOP w0.15: R18.1 36.9,48.95 36.75,48.8 v1(36.75,48.67) ; U2.6 v1(29.33,38.35)
  L3 w0.15: v1(36.75,48.67) 36.3,49.12 35.23,49.12 34.66,49.69 34.66,49.69 34.5,49.85 33.07,49.85 32.3,49.07 32.3,47.48 32.31,47.47 32.31,47.44 33.04,46.71 33.04,45.38 32.98,45.32 32.98,43.15 31.47,41.65 31.47,40.05 30.78,39.36 30.78,39.03 30.76,39 30.76,38.99 30.53,38.76 30.52,38.76 30.1,38.35 v1(29.33,38.35)
DIO36_FLASH_MOSI: length 79.9
  TOP w0.15: U3.5 35.45,71.43 v1(37.67,71.43) ; U1.22 34.04,51.6 34.22,51.78 35.24,51.78 35.34,51.88 38.17,51.88 38.23,51.82 38.26,51.82 38.38,51.69 38.74,51.69 38.86,51.82 40.11,51.82 40.65,51.28 41.4,51.28 41.67,51.55 v1(41.7,51.55) 41.7,58.8 v1(41.9,59)
  L3 w0.15: v1(37.67,71.43) 38.32,71.43 38.35,71.45 39.46,71.45 39.9,71.01 39.9,70.32 38.88,69.3 31.2,69.3 30.3,68.4 30.3,66.68 33.93,63.05 37.85,63.05 v1(41.9,59) ; P5.3 44.42,36.68 44.42,35.25 45.6,34.07 48.95,34.07 49.8,34.93 49.8,38.35 50.67,39.22 50.67,41.4 49.25,42.82 47.85,42.82 41.57,49.1 41.57,51.15 41.67,51.25 41.67,51.53 v1(41.7,51.55)
DIO37_FLASH_MISO: length 56
  TOP w0.15: U3.2 v1(32.27,72.65) ; U1.23 34.02,52 34.09,52.07 35.12,52.07 35.22,52.18 38.3,52.18 38.36,52.12 v1(38.56,52.12) 40.33,52.12 40.34,52.11 40.44,52.11 v1(40.85,51.7)
  L3 w0.15: v1(32.27,72.65) 30.72,72.65 27.6,69.53 27.6,65.53 33.57,59.55 33.57,59.55 35.55,57.57 36.48,57.57 38.52,55.53 38.52,52.92 38.47,52.87 38.46,52.86 38.46,52.81 38.35,52.7 38.35,52.38 38.47,52.26 38.47,52.2 v1(38.56,52.12) ; P5.4 48.58,37.98 50.07,39.47 50.07,41.15 49,42.22 47.6,42.22 40.92,48.9 40.92,51.62 v1(40.85,51.7)
DIO38_FLASH_CS: length 66.3
  TOP w0.15: v1(31.22,73.15) R24.1 U3.1 ; 41.22,52.38 v1(41.22,52.35) 41.05,52.35 40.99,52.41 40.46,52.41 40.42,52.45 39.07,52.45 v1(38.89,52.63) 38.88,52.62 38.88,52.62 38.79,52.54 38.38,52.54 38.31,52.47 35.09,52.47 35.02,52.4 U1.24
  L3 w0.15: v1(38.89,52.63) 38.89,55.59 36.61,57.88 35.67,57.88 33.88,59.67 33.88,59.68 27.9,65.65 27.9,69.4 30.69,72.19 32.41,72.19 32.7,72.47 32.7,72.83 32.38,73.15 v1(31.22,73.15) ; v1(41.22,52.35) 41.22,52.2 41.21,52.19 41.21,52.16 41.27,52.1 41.27,48.97 47.72,42.53 49.12,42.53 50.38,41.28 50.38,39.35 49.47,38.45 49.47,35.03 48.82,34.38 46.45,34.38 45.72,35.1 P5.5
DIO39_FLASH_SCLK: length 70.8
  TOP w0.15: U1.25 38.21,52.8 38.49,53.07 39.08,53.07 39.23,52.93 40.55,52.93 v1(40.64,52.84) 40.72,52.93 40.72,57.65 40.55,57.82 v1(40.55,59.2) ; v1(36.02,71.95) 36.02,72 35.88,72.15 U3.6
  L3 w0.15: v1(40.55,59.2) 40.55,59.65 37.45,62.75 33.8,62.75 30,66.55 30,68.53 31.07,69.6 37.62,69.6 38.22,70.2 39.35,70.2 39.6,70.45 39.6,70.88 39.33,71.15 38.47,71.15 38.33,71.01 37.86,71.01 37.85,71 37.5,71 37.49,71.01 36.17,71.01 36.02,71.15 v1(36.02,71.95) ; P5.6 48.26,35.71 47.07,36.9 47.07,38.72 47.38,39.03 49.2,39.03 49.77,39.6 49.77,41.03 48.88,41.93 47.47,41.93 40.52,48.87 40.52,51.42 40.42,51.52 40.42,51.87 40.51,51.96 40.51,51.96 40.52,51.98 40.52,52.72 v1(40.64,52.84)
DIO40: length 39.4
  TOP w0.15: U1.41 29.55,57.2 30.6,58.25 30.6,58.72 31.15,59.28 31.15,59.3 31.4,59.55 32.52,59.55 33.8,60.82 v1(34.42,60.82) ; v1(39.17,70.71) 39.17,69.95 R8.2 R10.2
  L3 w0.15: v1(34.42,60.82) 34.77,60.47 36.15,60.47 36.52,60.1 36.56,60.1 37.01,59.65 38.3,59.65 38.55,59.9 38.55,61.22 37.32,62.45 33.68,62.45 29.7,66.43 29.7,68.65 30.95,69.9 35.2,69.9 36,70.7 37.98,70.7 37.98,70.71 v1(39.17,70.71)
DIO41: length 42.9
  TOP w0.15: U1.42 29.15,56.01 29.36,55.8 31.82,55.8 31.95,55.68 v1(32.77,55.68)
  L3 w0.15: J2.18 53.12,47.09 53.12,45.07 52.25,44.2 48.47,44.2 43.32,49.35 43.32,51.4 41.07,53.65 40.42,53.65 39.91,53.14 39.91,52.21 39.79,52.08 39.79,51.24 39.9,51.13 39.9,49.02 39.48,48.6 38.85,48.6 36.97,50.48 36.97,52.43 35.38,54.03 35.38,55.22 34.92,55.68 v1(32.77,55.68)
DIO42: length 46.7
  TOP w0.15: v1(31.2,55.38) 31.07,55.5 29.17,55.5 28.75,55.92 U1.43
  L3 w0.15: v1(31.2,55.38) 31.32,55.25 32.94,55.25 33.03,55.34 34.81,55.34 35.07,55.07 35.07,53.9 36.67,52.3 36.67,50.35 38.73,48.3 39.6,48.3 40.2,48.9 40.2,51.25 40.12,51.33 40.12,51.4 40.09,51.44 40.09,51.96 40.21,52.08 40.21,53.01 40.55,53.35 40.95,53.35 43.02,51.28 43.02,49.22 48.35,43.9 52.38,43.9 53.42,44.95 53.42,49.18 52.07,50.53 J2.16
DIO43: length 27.8
  TOP w0.15: v1(28.6,55.45) 28.6,55.63 28.35,55.88 U1.44
  L3 w0.15: J1.18 9.23,48.5 15.35,48.5 15.41,48.44 15.73,48.44 15.79,48.5 21.27,48.5 v1(21.45,48.32) 21.47,48.32 22.79,49.65 23.85,49.65 24.82,48.68 25.47,48.68 27.27,50.47 27.27,55.17 27.52,55.42 27.52,55.43 27.77,55.68 28.42,55.68 28.6,55.5 v1(28.6,55.45)
DIO44: length 27.5
  TOP w0.15: v1(27.95,55.25) U1.45
  L3 w0.15: J1.20 8.97,45.5 18.95,45.5 v1(21.02,47.57) 21.27,47.82 21.73,47.82 22.68,48.77 22.7,48.77 22.75,48.82 24.25,48.82 24.7,48.38 25.72,48.38 27.6,50.25 27.6,54.9 v1(27.95,55.25)
DIO45: length 61.1
  TOP w0.15: R19.1 25.07,56.3 25.95,56.3 v1(25.97,56.28) 26.07,56.28 26.65,55.7 27.23,55.7 27.55,56.02 U1.46 ; v1(37.7,58.53) 36.1,56.93 34.92,56.93 v1(34.11,56.11)
  L3 w0.15: J2.7 41.97,68.4 31.57,68.4 31.2,68.03 31.2,67.05 34.3,63.95 38.4,63.95 42.33,60.03 42.92,59.43 42.92,58.57 42.3,57.95 38.27,57.95 v1(37.7,58.53) ; v1(34.11,56.11) 33.17,57.05 26.75,57.05 v1(25.97,56.28)
DIO46: length 81.4
  TOP w0.15: U1.58 23.6,52 23.58,51.97 22.7,51.97 22.1,52.57 19.25,52.57 18.85,52.97 18.85,55.82 19.52,56.5 19.52,57.45 R20.1 v1(19.4,58.1)
  L3 w0.15: J2.3 49.53,66.79 48.35,67.97 48.35,73.63 49.48,74.76 49.48,75.12 49.06,75.54 47.49,75.54 46.38,74.43 46.38,71.31 45.09,70.02 43.55,70.02 42.88,70.7 42.88,73.62 41.6,74.9 40.17,74.9 39.45,74.18 34.54,74.18 34.26,74.46 30.86,74.46 30.76,74.37 29.49,74.37 28.88,74.97 25.95,74.97 23.47,72.5 17.17,72.5 16.15,71.47 16.15,66.52 19.52,63.15 19.52,58.23 v1(19.4,58.1)
DIO47: length 79.6
  TOP w0.15: U1.59 25.32,51.6 25.3,51.62 23.65,51.62 23.6,51.68 22.57,51.68 21.97,52.28 19.1,52.28 18.55,52.82 18.55,55.95 18.67,56.07 R21.1 18.67,56.82 18.82,56.97 v1(18.95,56.97)
  L3 w0.15: 49.51,68.44 J2.1 49.53,74.39 49.78,74.64 49.78,75.24 49.19,75.84 47.15,75.84 44.89,73.58 44.89,70.72 44.51,70.34 43.67,70.34 43.17,70.83 43.17,73.97 41.9,75.25 40.1,75.25 40.05,75.2 40.05,75.2 39.32,74.47 34.67,74.47 34.38,74.76 30.73,74.76 30.63,74.66 29.61,74.66 28.75,75.53 26.07,75.53 25.82,75.28 25.82,75.28 23.35,72.8 17.05,72.8 15.85,71.6 15.85,66.4 18.95,63.3 v1(18.95,56.97)
LP_RESET: length 17
  TOP w0.15: v1(50.95,59.35) 51.02,59.35 J2.10 ; R10.1 R11.1 v1(42.25,67.5)
  L3 w0.15: v1(42.25,67.5) 42.25,65.72 48.44,59.53 50.77,59.53 v1(50.95,59.35)
RX_TX: length 14.7
  TOP w0.15: U1.7 29.15,49.18 28.88,49.45 v1(28.88,49.53)
  TOP w0.3: v1(23.65,47.75) 23.7,47.75 23.8,47.65 24.3,47.65 ; 26.91,45.07 L40.1 26.29,45.07 v1(26.29,44.61) 26.28,44.62 C56.2 ; C11.2 24.3,47.65 ; 24.3,47.65 L12.1
  L3 w0.3: v1(23.65,47.75) 23.7,47.75 23.8,47.65 27.77,47.65 ; 27.77,47.65 28.88,48.75 v1(28.88,49.53) ; 27.77,47.65 27.77,45.1 27.28,44.61 v1(26.29,44.61)
WMCU_RESET: length 95.4
  TOP w0.15: v1(43.13,69.83) 42.32,69.83 R11.2 41.5,70.65 39.75,70.65 39.6,70.8 39.6,70.88 39.35,71.13 39,71.13 38.98,71.11 38.56,71.11 37.95,70.5 37.95,70.15 R9.2 ; U1.49 25.13,55.6 24.7,56.03 24.68,56.03 24.18,56.53 R1.1 23.4,56.53 C54.1 23.1,56.32 22.7,56.72 21.57,56.72 v1(20.55,57.75) ; v1(29.42,77.15) 29.42,77.07 29.27,76.93 v1(29.27,73.97) ; CR2.2 52.12,82.05 52.52,81.65 52.52,80.82 51.43,79.72 50.15,79.72 49.06,78.63 P6.10 v1(49.06,74.94)
  L3 w0.15: v1(20.55,57.75) 20.44,57.86 20.44,62.66 16.45,66.65 16.45,71.35 17.3,72.2 23.6,72.2 26.07,74.68 28.57,74.68 v1(29.27,73.97) 33.63,73.97 33.81,74.16 34.13,74.16 34.42,73.88 39.57,73.88 40.3,74.6 41.47,74.6 42.57,73.5 42.57,70.39 v1(43.13,69.83) 43.25,69.72 46.3,69.72 46.96,70.39 46.96,74.6 47.61,75.24 48.76,75.24 v1(49.06,74.94) ; J4.10 30.51,87.01 29.38,85.88 29.38,78.97 29.42,78.93 v1(29.42,77.15)
WMCU_RXD: length 91.2
  TOP w0.15: v1(26.38,77.15) v1(26.38,73.95) ; v1(37.45,53.3) 37.35,53.2 U1.26
  L3 w0.15: J1.5 6.33,64.02 5.78,64.57 5.77,64.57 4.98,65.36 4.98,66.48 5.85,67.35 6.71,67.35 7.38,68.03 7.38,71.93 9.22,73.78 15.9,73.78 16.42,74.3 22.72,74.3 25.2,76.78 25.2,76.78 25.57,77.15 v1(26.38,77.15) 26.5,77.28 26.5,85.97 25.45,87.01 J4.14 ; v1(26.38,73.95) 26.2,73.95 23.85,71.6 17.55,71.6 17.05,71.1 17.05,66.9 21.55,62.4 29.45,62.4 32.07,59.78 32.08,59.78 32.67,59.18 32.67,59.17 35.17,56.68 36.11,56.68 37.45,55.33 v1(37.45,53.3)
WMCU_SWO: length 108.4
  TOP w0.15: CR3.5 45.11,82.57 44.8,82.27 44.8,79.78 43.27,78.25 43.27,76.97 v1(40.47,74.18) ; v1(28.3,73.97) 28.3,76.97 28.42,77.1 v1(28.42,77.22) ; U1.36 31.55,57.05 33.9,59.4 v1(34.88,59.4)
  L3 w0.15: J2.9 48.7,58.3 38.92,68.07 38.63,68.07 38.6,68.1 31.7,68.1 31.5,67.9 31.5,67.18 34.43,64.25 38.53,64.25 42.45,60.32 42.45,60.32 43.22,59.55 43.22,58.45 42.43,57.65 37.5,57.65 35.85,59.3 35.37,59.3 35.27,59.4 v1(34.88,59.4) 34.57,59.4 34.17,59.8 34.17,59.8 28.2,65.78 28.2,69.28 30.81,71.88 33.36,71.88 34.42,72.95 34.42,72.97 ; v1(28.42,77.22) 28.27,77.38 28.27,84.18 J4.11 ; 34.42,72.97 35,73.55 35.32,73.55 35.35,73.57 39.88,73.57 v1(40.47,74.18) ; 34.42,72.97 34.01,73.39 33.81,73.39 33.53,73.68 29.58,73.68 29.38,73.48 29.17,73.48 29.1,73.55 28.67,73.97 v1(28.3,73.97)
WMCU_TCK: length 68.7
  TOP w0.15: CR2.6 49.9,82.05 v1(49.65,81.8) ; v1(41.2,72.93) 41.2,72.98 43.25,75.03 44.63,75.03 45.25,75.64 P6.4 45.25,78.53 45.77,79.05 46.57,79.05 47.47,79.95 47.9,79.95 48.15,80.2 48.15,80.63 48.3,80.78 v1(48.3,81.23) ; v1(34.7,71) 34.32,70.62 R5.2 ; U1.33 33.12,56.45 33.26,56.59 33.26,57.06 34.34,58.14 35.54,58.14 37.7,60.3 v1(37.7,60.88)
  L3 w0.15: J4.6 36.76,85.85 38.88,85.85 39.19,85.54 46.51,85.54 48.3,83.75 v1(48.3,81.23) 49.07,81.23 v1(49.65,81.8) ; v1(41.2,72.93) 40.5,72.93 39.75,72.18 36.83,72.18 36.33,72.68 35.72,72.68 34.7,71.65 v1(34.7,71) 34.2,70.5 30.7,70.5 29.1,68.9 29.1,66.18 33.43,61.85 36.85,61.85 37.7,61 v1(37.7,60.88)
WMCU_TMS: length 74
  TOP w0.15: v1(49.82,81.25) 50.15,81.25 CR2.7 ; v1(40.95,72) 40.95,72.05 40.62,72.38 40.62,73.44 P6.2 43.98,78.1 45.22,79.35 46.45,79.35 47.39,80.29 47.64,80.29 v1(47.72,80.38) ; v1(38.12,60.07) 37.95,60.07 35.8,57.93 35.75,57.93 35.67,57.84 34.47,57.84 33.6,56.97 U1.32 ; v1(35.22,70.65) 35.8,70.07 R4.2
  L3 w0.15: J4.8 34.52,85.55 38.75,85.55 39.42,84.88 39.42,84.23 40.22,83.43 41.4,83.43 43.2,85.23 46.4,85.23 47.96,83.67 47.96,81.92 47.88,81.83 47.88,81 47.72,80.85 v1(47.72,80.38) 48.27,80.38 48.74,80.84 49.41,80.84 v1(49.82,81.25) ; v1(40.95,72) 40.6,72.35 40.35,72.35 39.88,71.88 36.7,71.88 36.2,72.38 35.85,72.38 35.22,71.75 v1(35.22,70.65) 34.77,70.2 30.82,70.2 29.4,68.78 29.4,66.3 33.55,62.15 37.2,62.15 38.17,61.18 38.17,60.12 v1(38.12,60.07)
WMCU_TXD: length 97
  TOP w0.15: U1.27 36.88,53.6 v1(36.97,53.7) ; v1(27.35,77.15) 27.35,74 v1(27.3,73.95)
  L3 w0.15: J1.7 7.52,62.03 7.52,62.82 7.52,62.82 7.52,64.23 6.88,64.87 5.9,64.87 5.28,65.49 5.28,66.35 5.9,66.97 7.02,66.97 7.68,67.63 7.68,71.81 9.35,73.47 16.02,73.47 16.55,74 22.85,74 25.32,76.47 25.32,76.47 25.57,76.72 26.92,76.72 v1(27.35,77.15) 27.47,77.28 27.47,83.07 26.8,83.75 26.8,85.84 J4.12 ; v1(27.3,73.95) 27.3,74.01 27.15,74.16 26.77,74.16 26.55,74.38 26.2,74.38 23.72,71.9 17.42,71.9 16.75,71.22 16.75,66.77 21.42,62.1 29.32,62.1 31.95,59.47 31.95,59.47 32.38,59.05 32.38,59.05 35.05,56.38 35.98,56.38 36.97,55.38 v1(36.97,53.7)
WMCU_VDD: length 146.7
  TOP w0.15: R2.2 v1(4.18,44.93) ; v1(4.22,47.62) 3.65,47.05 R3.2
  TOP w0.25: R25.2 33.17,74.53 v1(32.52,75.18) ; R22.2 v1(38.42,75) ; R24.2 31.65,73.95 R23.2 v1(30.47,75.05)
  TOP w0.3: v1(43.92,70.82) 43.92,72.89 P6.1 ; FL1.2 23,60.43 22.92,60.5 v1(22.92,60.5) ; v1(46.12,80.43) CR3.8 ; v1(51.15,80.65) 51.15,81.4
  L3 w0.15: 4.22,44.97 v1(4.18,44.93) ; 4.1,48.55 4.22,48.68
  L3 w0.5: v1(46.12,80.43) 46.22,80.32 46.22,76.18 ; 22.89,85.94 J4.16 23.97,87.01 ; v1(43.92,70.82) 43.92,76.18 ; 38.38,76.18 38.42,76.12 v1(38.42,75) ; 51.15,76.2 v1(51.15,80.65)
  L3 w1: 4.22,44.97 v1(4.22,47.62) 4.22,66.75 5.94,68.46 J1.1 6.33,72.06 10.45,76.18 v1(22.77,76.18) v1(23.52,76.18) 23.52,82.7 23.27,82.95 ; P3.1 52.34,35.44 54.07,37.17 54.07,43.55 54.92,44.4 54.92,51.82 54.07,52.67 54.07,70.2 51.17,73.1 51.17,76.18 50.7,76.65 46.7,76.65 46.22,76.18 v1(31.8,76.18) v1(31,76.18)
  vias: v1(22.52,60.9) v1(23.17,60.88) v1(23.6,60.6)
XDS_BOARDID_SCL: length 13.6
  TOP w0.15: v1(11.95,83.72) U4.1
  L3 w0.15: v1(11.95,83.72) 11.98,83.72 13.57,82.12 19.88,82.12 22.22,84.48 J4.15
XDS_BOARDID_SDA: length 8.5
  TOP w0.15: v1(13.85,83.72) U4.3
  L3 w0.15: J4.17 18.8,82.93 14.65,82.93 v1(13.85,83.72)
XDS_GPIO1: length 81.3
  TOP w0.15: CR3.1 v1(46.82,81.1) ; R19.2 v1(25.26,57.11)
  L3 w0.15: v1(46.82,81.1) 46.82,82.23 47.38,82.78 47.38,83.2 46.7,83.88 44.77,83.88 44.76,83.89 44.44,83.89 44.43,83.88 44,83.88 43.25,83.12 39.48,83.12 38.14,84.47 ; 38.14,84.47 36.79,83.12 32.27,83.12 32.17,83.02 31.85,83.02 31.35,82.52 31.35,81.93 31,81.58 31,78.08 29.35,76.43 25.7,76.43 25.45,76.18 25.45,76.18 22.97,73.7 16.67,73.7 16.15,73.18 9.47,73.18 8.77,72.48 8.77,71.37 11.85,68.3 11.85,57.33 12.94,56.24 19.91,56.24 20.32,56.65 v1(20.5,56.65) ; 38.14,84.47 J4.3
  BOTTOM w0.15: v1(25.26,57.11) 24.88,57.11 24.07,56.3 22.31,56.3 21.96,56.65 v1(20.5,56.65)
XDS_GPIO2: length 64.3
  TOP w0.15: v1(18.25,57.95) 18.62,57.57 R20.2 ; v1(47.5,82.07) CR3.2 ; v1(31.82,81.38) 31.81,81.39 30.52,81.39 v1(30.47,81.35)
  L3 w0.15: v1(30.47,81.35) 30.47,81.48 30.92,81.93 30.92,82.63 30.94,82.65 30.94,82.92 31.35,83.32 32.05,83.32 32.15,83.43 34.54,83.43 J4.5 ; v1(18.25,57.95) 18.38,58.07 18.38,63.45 15.55,66.27 15.55,71.72 16.92,73.1 23.22,73.1 25.7,75.57 25.7,75.57 25.95,75.82 29.6,75.82 31.6,77.83 31.6,81.15 v1(31.82,81.38) 46.02,81.38 46.4,81 46.4,80.92 46.65,80.67 47.12,80.67 47.57,81.12 47.57,81.9 47.5,81.97 v1(47.5,82.07)
XDS_GPIO3: length 59.5
  TOP w0.15: 30.51,82.37 v1(30.47,82.32) v1(31.82,82.32) ; v1(46.82,83.05) CR3.3 ; v1(18,57) 18.1,56.9 18.1,56.44 R21.2
  L3 w0.15: 31.82,82.25 32.4,82.82 46.07,82.82 46.3,83.05 v1(46.82,83.05) ; 31.82,82.25 v1(31.82,82.32) ; 31.82,82.25 31.82,81.98 31.3,81.45 31.3,77.95 29.47,76.12 25.82,76.12 25.57,75.88 23.1,73.4 16.8,73.4 15.25,71.85 15.25,66.15 16.99,64.41 16.99,58.34 17,58.33 17,57.57 17.62,56.95 17.95,56.95 v1(18,57) ; 30.52,82.28 v1(30.47,82.32) 30.51,82.37 J4.9
N3099875: length 2.9
  TOP w0.2: 25.92,47.65 26.75,48.48 U1.1
  TOP w0.25: L11.1 25.92,47.65
  TOP w0.3: L11.1 25.74,47.65 L12.2 25.28,47.25 24.88,46.85 C13.1
N3099951: length 1.2
  TOP w0.3: 24.4,45.96 24.41,45.95 L13.2 ; 24.4,45.96 24.4,45.95 L14.1 ; 24.4,45.96 C13.2
N3100073: length 1.5
  TOP w0.3: L14.2 23.79,45.34 C14.2 23.79,43.96 L15.1
N3100081: length 1.3
  TOP w0.3: C16.1 23.81,42.11 C15.2 23.8,42.76 L15.2 23.8,43.39
N3100105: length 5.9
  TOP w0.3: C17.1 33.43,30.35 J3.1
N3100141: length 3.2
  TOP w0.2: U1.2 27.15,48.25 26.25,47.35
  TOP w0.25: 26.25,47.35 L11.2
  TOP w0.3: L11.2 26.25,47.24 C12.2 25.36,46.35 L13.1
N3100321: length 6.9
  TOP w0.2: 31.93,37.55 U2.1
  TOP w0.3: 31.93,37.55 32.2,37.55 32.99,36.76 32.99,33.53 CR1.2 C17.2
N3100543: length 8.1
  TOP w0.2: U2.8 29.53,37.55
  TOP w0.3: C16.2 23.8,41.15 27.4,37.55 29.53,37.55
N3100575: length 1.6
  TOP w0.2: U2.5 29.79,38.94
  TOP w0.3: 29.79,38.94 C27.2
N3100757: length 1.2
  TOP w0.2: L41.1 27.55,47.7 U1.3
N3100925: length 1.2
  TOP w0.2: U1.4 27.95,47.7 L44.1
N3100985: length 2.8
  TOP w0.2: U1.5 28.35,48.12 29.42,47.05 29.55,47.05 L31.1
N3100993: length 3
  TOP w0.15: 32.05,31.7 C18.2
  TOP w0.3: Z1.1 32.05,31.7
N3100997: length 2.6
  TOP w0.2: L32.1 30.05,47.45 29.55,47.45 28.75,48.25 U1.6
N3101199: length 13.1
  TOP w0.15: C50.1 39.42,43.55 Y1.1 37.85,43.55 37.21,44.19 37.21,44.87 36.24,45.84 36.09,45.84 35.92,46.01 35.88,46.01 35.17,46.72 32.88,46.72 32.79,46.81 32.14,46.81 31.16,47.8 30.03,47.8 29.55,48.28 U1.8
N3101207: length 11.3
  TOP w0.15: U1.9 29.95,48.31 30.16,48.1 31.28,48.1 32.27,47.11 32.91,47.11 33,47.03 35.29,47.03 36.01,46.31 36.04,46.31 36.21,46.14 36.46,46.14 36.7,45.9 Y1.2 39.55,45.9 C51.1
N3101223: length 6.8
  TOP w0.15: C52.1 19.6,49.3 Y2.1 22.92,49.3 23.27,49.65 25.13,49.65 25.48,50 U1.63
N3101377: length 3.1
  TOP w0.3: Z2.1 Z4.1 Z3.2 Z1.2 29.1,31.19
N3101433: length 1.7
  TOP w0.3: A1.1 Z2.2
  vias: v1(10.4,18) v1(10.4,13.11) v1(10.41,7.97) v1(10.41,2.97) v1(11.79,14.53) v1(11.79,4.48) v1(12.84,11.6) v1(12.83,1.6) v1(13.77,18) v1(14.82,13) v1(14.8,3) v1(15.89,8) v1(17.77,16.6) v1(17.84,11.6) v1(17.83,1.6) v1(18.77,18) v1(18.91,6.6) v1(19.8,3) v1(19.82,13) v1(20.89,8) v1(22.77,16.6) v1(22.85,11.6) v1(22.82,1.6) v1(23.77,18) v1(23.91,6.6) v1(24.8,3) v1(24.82,13) v1(25.89,8) v1(27.85,11.6) v1(27.82,1.6) v1(28.4,25.05) v1(28.4,20.05) v1(28.91,6.6) v1(29.8,21.55) v1(29.8,16.6) v1(29.8,3) v1(29.82,13) v1(30.89,8) v1(32.85,11.6) v1(32.82,1.6) v1(33.91,6.6) v1(34.8,3) v1(34.82,13) v1(35.89,8) v1(37.85,11.6) v1(37.82,1.6) v1(38.91,6.6) v1(39.8,3) v1(39.82,13) v1(40.89,8) v1(42.85,11.6) v1(42.82,1.6) v1(43.91,6.6) v1(44.8,3) v1(44.82,13) v1(46.4,9.56) v1(47.79,11.54) v1(47.79,6.61) v1(47.77,1.6)
N3101449: length 7
  TOP w0.15: C53.1 19.64,51.14 Y2.3 22.11,51.14 23.3,49.95 25,49.95 25.28,50.23 25.45,50.4 U1.62
N3101777: length 1.9
  TOP w0.3: L31.2 30.45,46.25 L34.1 30.85,45.84 L35.2 31.74,44.95 C32.1
N3101817: length 2.5
  TOP w0.3: 32.6,44.59 32.61,44.59 C35.1 33.25,43.95 L37.1 33.13,43.78 33.13,43.76 32.85,43.48 C36.1 ; 32.6,44.59 32.18,44.59 C32.2 ; 32.6,44.59 L36.2
N3101861: length 2.2
  TOP w0.3: L39.1 C37.1 L37.2 33.25,43.1 C36.2
N3101937: length 1.3
  TOP w0.3: C39.1 C38.1 L39.2
N3101953: length 4.3
  TOP w0.2: U2.4 31.93,38.75
  TOP w0.3: 31.93,38.75 34.32,38.75 34.75,39.18 C39.2
N3101989: length 1.9
  TOP w0.3: L32.2 30.8,46.7 L34.2 31.25,46.25 C31.1 32.1,45.4 L36.1
N3109894: length 21.5
  TOP w0.15: v1(35.8,67.5) R4.1
  L3 w0.15: J2.13 46.7,56.05 46.7,57.78 44.42,60.05 42.95,61.53 42.95,61.53 39,65.47 37.9,65.47 35.87,67.5 v1(35.8,67.5)
N3109960: length 25.2
  TOP w0.15: v1(34.32,67.5) R5.1
  L3 w0.15: J2.15 46.1,54.11 46.1,57.95 44.12,59.93 44.12,59.93 42.83,61.22 38.88,65.18 37.77,65.18 37.7,65.25 36.62,65.25 34.36,67.5 v1(34.32,67.5)
N3110034: length 28.7
  TOP w0.15: R6.1 32.83,67.97 v1(33.27,67.53)
  L3 w0.15: v1(33.27,67.53) 35.92,64.88 38.75,64.88 42.7,60.93 43.82,59.8 43.82,59.8 45.1,58.52 45.1,52.57 J2.17
N3110086: length 32.6
  TOP w0.15: R7.1 31.35,67.93 31.7,67.57 v1(32,67.57) ; v1(48.28,46.86) J2.19
  L3 w0.15: v1(48.28,46.86) 44.75,50.38 44.75,58.45 43.52,59.68 42.58,60.62 42.58,60.62 38.63,64.57 34.95,64.57 32,67.53 v1(32,67.57)
N3110356: length 2.1
  TOP w0.15: R15.2 22.88,68 P1.1
N3110380: length 2.1
  TOP w0.15: R14.2 21.85,70.52 21.84,70.53 P1.3
N3110768: length 1.3
  TOP w0.15: R12.1 5.53,73.2 SW1.4
N3110772: length 3.3
  TOP w0.15: R13.1 54.75,70.2 54.75,72.82 54.4,73.18 SW2.3
N3110876: length 1.4
  TOP w0.15: R14.1 24.67,70.52 CR4.2
N3110880: length 1.4
  TOP w0.15: CR5.2 24.67,68 R15.1
N3111246: length 2.9
  TOP w0.25: U3.8 C55.1 35.97,73.97 35.57,74.38 R25.1
N3111262: length 3.3
  TOP w0.15: R22.1 37.32,72.35 37.02,72.65 U3.7
N3111266: length 2.4
  TOP w0.15: U3.3 31.95,72.15 31.75,72.35 R23.1
N3254079: length 2.2
  TOP w0.25: U1.47 27.15,58.57 L1.2
N3268642: length 0.6
  TOP w0.3: L38.1 C37.2
N3281348: length 1.2
  TOP w0.15: U1.31 33.62,55.22 34.5,55.22 C9.1
N3492676: length 1.3
  TOP w0.3: L27.2 28.41,40.14 Z7.1 C27.1
N3492704: length 0.6
  TOP w0.3: Z7.2 Z8.1
N3493209: length 2.6
  TOP w0.3: 27.46,44.44 C57.1 27.45,45.06 L40.2 27.47,45.09 L42.1 C58.1 27.42,46.43 L41.2
N3493257: length 2.5
  TOP w0.3: 28.1,43.86 L45.2 28.11,43.87 27.78,43.54 ; 27.78,43.54 27.78,43.23 C59.1 L43.1 ; 27.78,43.54 27.77,43.54 C57.2 27.46,43.87 27.62,43.7 ; 27.78,43.54 27.78,43.54 ; 27.78,43.54 27.78,43.2 27.78,43.2
N3493329: length 1.3
  TOP w0.3: L27.1 C60.1 L43.2
N3493341: length 2.6
  TOP w0.3: L44.2 28.07,46.41 C58.2 L42.2 28.07,45.69 28.07,45.1 C61.1 L45.1

## Copper pours and planes (outline as drawn)
GND on TOP: 0.5,87.99 0.65,88.34 1,88.49 57.5,88.49 57.85,88.34 58,87.99 58,81.6 57.74,80.1 57.01,78.76 55.8,75.3 57.01,71.84 57.74,70.5 58,69 58,26.55 29.75,26.55 29.75,31 32.35,31 32.35,29.7 36.07,29.7 37.04,28.2 38.72,27.62 41.45,30.35 38.72,33.08 37.04,32.5 36.07,31 33.65,31 33.65,37.03 32.6,38.07 31.07,38.07 31.07,36.95 31.88,36.95 32.35,36.47 32.35,32.4 28.45,32.4 28.45,26.55 0.5,26.55 0.5,69 0.76,70.5 1.49,71.84 2.7,75.3 1.49,78.76 0.76,80.1 0.5,81.6 ; 11 cut-outs
VDDR on L3: 29.2,59.57 29.2,58.3 29.42,58.07 29.8,58.07 29.9,58.18 29.9,59.35 29.6,59.65 29.27,59.65
VDDS on L3: 24.32,58 22.75,58 22.4,57.65 22.4,56.97 23.12,56.25 23.82,56.25 24.45,56.88 24.45,57.88
(no net) on TOP: 22.3,59 22.3,56.93 23.85,56.93 23.85,59
(no net) on TOP: 29.32,58.22 29.92,58.22 29.92,59.55 29.02,60.45 28.12,60.45 28.12,59.32 29.32,59.32
WMCU_VDD on TOP: 22.3,61.1 22.3,59.2 23.85,59.2 23.85,61.1
WMCU_VDD on BOTTOM: 22.27,75.25 22.27,60.32 23.88,60.32 23.88,75.25
WMCU_VDD on BOTTOM: 22.27,76.4 22.27,74.82 32.77,74.82 32.77,76.4
WMCU_VDD on L3: 22.3,61.1 22.3,60.28 23.85,60.28 23.85,61.1
WMCU_VDD on L3: 22.9,87.32 23.62,87.32 24.42,87.25 24.42,83.62 23.22,82.42 22.77,82.98 22.62,85.98 22.17,87.12
N3101433 on TOP (solid shape): 30.1,16.3 12.1,16.3 12.1,13.3 48.1,13.3 48.1,6.3 12.1,6.3 12.1,3.3 48.1,3.3 48.1,1.3 10.1,1.3 10.1,8.3 46.1,8.3 46.1,11.3 10.1,11.3 10.1,18.3 28.1,18.3 28.1,25.3 30.1,25.3
N3101433 on BOTTOM (solid shape): 30.1,16.3 12.1,16.3 12.1,13.3 48.1,13.3 48.1,6.3 12.1,6.3 12.1,3.3 48.1,3.3 48.1,1.3 10.1,1.3 10.1,8.3 46.1,8.3 46.1,11.3 10.1,11.3 10.1,18.3 28.1,18.3 28.1,25.3 30.1,25.3

Small or netless copper shapes (teardrops, artwork): 142 on TOP, 10 on BOTTOM, 1 on L2, 188 on L3

## Text on the board
Ref Des/Silkscreen Bottom: J1 | 1 | 10 | 21 | 30 | J3 | J4 | 31 | 40 | 11 | 20 | J2 | DIO23 | DIO22 | DIO24 | DIO12 | DIO13 | DIO26 | DIO43 | DIO44 | DIO25 | DIO27 | DIO28 | DIO29 | DIO30 | GND | DIO3 | DIO34 | DIO36 | DIO38 | DIO35 | DIO37 | DIO39 | DIO46 | DIO20 | DIO18 | BPRST | DIO47 | DIO45 | DIO15 | DIO9 | DIO8 | DIO14 | DIO19 | DIO11 | LPRST | DIO42 | DIO41 | DIO10 | DIO21 | DIO4 | DIO5 | TMS | TCK | DIO16 | DIO17
User.Comments: Rev. A | Milling tool 2.0 mm TYP | MCU087 | RED | BOTTOM LAYER
Ref Des/Silkscreen Top: DIO23 | DIO12 | DIO13 | DIO22 | DIO24 | J1 | DIO15 | BTN-1 | 10 | 1 | 21 | 30 | J3 | DIO25 | DIO26 | DIO27 | DIO28 | DIO29 | DIO30 | DIO43 | DIO44 | 2 | Red  : DIO6 | Green: DIO7 | CC-ANTENNA-DK | Mount for: | BP  LP | LP-EM-CC1354P10-1 | Rev: A   MCU087 | DIO47 | DIO46 | DIO20 | DIO45 | DIO18 | BPRST | JTAG | J4 | 40 | 31 | 20 | 11 | J2 | DIO19 | DIO11 | DIO14 | LPRST | DIO9 | DIO8 | DIO42 | DIO41 | DIO4 | DIO21 | DIO5 | DIO10 | DIO16 | DIO17 | TMS | TCK | Extension | LEDs | GND | 5V | 3V3 | RXD | TXD | SWO | nRST | GPIO3 | TDI | TDO | GPIO2 | R9 | GPIO1 | R8 | R10 | R11 | BTN-2
XSECTION_CHART: L1: TOP CONDUCTOR - COPPER + PLATING 0.035 MM | *  DIELECTRIC - FR-4 0.175 MM (TOP PRIORITY,  AFTER PRESS) | L2: L2 PLANE - COPPER 0.035 MM | *  DIELECTRIC - FR-4 1.11 MM | L3: L3 PLANE - COPPER 0.035 MM | *  DIELECTRIC - FR-4 0.175 MM | L4: BOTTOM CONDUCTOR - COPPER + PLATING 0.035 MM | DESIGN CROSS SECTION CHART | ___________________________ | TOTAL THICKNESS 1.6 MM
PAGE_OUTLINE: LP-EM-CC1354P10-1
User.27: FIGURE | FINISHED_SIZE | 0.2 | 1.05 | 1.1 | 3.2 | 0.899 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | PLATED | NON-PLATED | QTY | 1022 | 82 | 1 | 4 | 2
