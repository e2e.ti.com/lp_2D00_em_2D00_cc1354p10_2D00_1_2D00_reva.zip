# OrCAD Capture schematic lp-em-cc1354p10-1.DSN, sheet 1 of 4 (continued)
## Library data of the parts (continued)
L12 L13 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 3.7nH, -0.1nH/+0.1nH, 0.4A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-0015.pdf; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=97117; BU Name: DYNAMIC PRECISION GDANSK; Budget Currency: EUR; Budget Price: 0.03371; Client Status: UNDER_REVIEW; Core Material: NON-MAGNETIC; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx?la=en-gb; Datasheet URL 1: http://psearch.murata.com/inductor/product/LQP03TN2N4B02%23.pdf; Datasheet URL 2: http://www.murata.com/~/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 6GHz; Mass: 0.0002g; Max Oper Temp: +125DEGC; Max Tol: +0.1nH; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1nH; Min Oper Temp: -55DEGC; Min Tol: -0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06940; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06940; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Resistance: 0.3; Revision: R020; RoHS Status: ROHS_COMPLIANT; Rtd Current: 0.5A; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN3N7B02J; Vendor Part Status: Active; Weight: 0.0002g
L14 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 3.4nH, -0.1nH/+0.1nH, 0.45A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-0015.pdf; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=97103; BU Name: DYNAMIC PRECISION GDANSK; Budget Currency: EUR; Budget Price: 0.03371; Client Status: UNDER_REVIEW; Core Material: NON-MAGNETIC; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx?la=en-gb; Datasheet URL 1: http://psearch.murata.com/inductor/product/LQP03TN1N0B02%23.pdf; Datasheet URL 2: http://www.murata.com/~/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 7GHz; Mass: 0.0002g; Max Oper Temp: +125DEGC; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1nH; Min Oper Temp: -55DEGC; Min Tol: -0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06937; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06937; Part Type: Inductor|RF|CHIP|0201; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jun 27, 2018; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Resistance: 0.25; Revision: R021; RoHS Status: ROHS_COMPLIANT; Rtd Current: 0.75A; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN3N4B02J; Vendor Part Status: Active; Weight: 0.0002g
L15 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 3.9nH, -0.1nH/+0.1nH, 0.5A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: IND_LQP03HQ_A2L,IND_LQP03HQ_A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-0021.pdf; Budgetary Price: 0.0576 USD; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx?la=en-gb; Frequency: 7GHz; Lead Time: 11; Mass: 0.00022g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-07901; PCB Package: 0201; Packing Size: 15000; Packing Type: Tape & Reel; Part Number: 03-07901; Part Type: Inductor|RF|CHIP|0201; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jan 15, 2018; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Resistance: 0.17; Revision: R015; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03HQ3N9B02D; Vendor Part Status: Active
L27 L43 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 6.8nH, -3%/+3%, 0.3A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-9101.pdf; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/emc/emifil/c51e.ashx?la=en&cvid=20220119013540000000; Frequency: 3.9GHz; Mass: 0.0002g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +3%; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -3%; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06950; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06950; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Rated Current: 0.3A; Resistance: 0.6; Revision: R025; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN6N8HZ2J; Vendor Part Status: Active
L31 L32 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 1nH, -0.1nH/+0.1nH, 0.75A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-0015.pdf; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=97103; BU Name: DYNAMIC PRECISION GDANSK; Budget Currency: EUR; Budget Price: 0.03371; Client Status: UNDER_REVIEW; Core Material: NON-MAGNETIC; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx?la=en-gb; Datasheet URL 1: http://psearch.murata.com/inductor/product/LQP03TN1N0B02%23.pdf; Datasheet URL 2: http://www.murata.com/~/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 17GHz; Mass: 0.0002g; Max Oper Temp: +125DEGC; Maximum Operating Temperature: +125DEGC; Min Oper Temp: -55DEGC; Min Tol: -0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06913; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06913; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Resistance: 0.1; Revision: R022; RoHS Status: ROHS_COMPLIANT; Rtd Current: 0.75A; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN1N0B02J; Vendor Part Status: Active; Weight: 0.0002g
L34 Z4 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 27nH, -3%/+3%, 0.14A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-9101.pdf; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=97154; BU Name: DYNAMIC PRECISION GDANSK; Budget Currency: N/A; Budget Price: N/A; Client Status: UNDER_REVIEW; Core Material: NON-MAGNETIC; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx?la=en-gb; Datasheet URL 1: http://psearch.murata.com/inductor/product/LQP03TN27NHZ2%23.pdf; Datasheet URL 2: http://www.murata.com/~/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 2GHz; Mass: 0.0002g; Max Oper Temp: +125DEGC; Max Tol: +3%; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +3%; Min Oper Temp: -55DEGC; Min Tol: -3%; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -3%; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06964; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06964; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Resistance: 2.3; Revision: R020; RoHS Status: ROHS_COMPLIANT; Rtd Current: 0.14A; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN27NHZ2J; Vendor Part Status: Active; Weight: 0.0002g
L35 L36 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 12nH, -3%/+3%, 0.25A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-9101.pdf; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=97146; BU Name: DYNAMIC PRECISION GDANSK; Budget Currency: N/A; Budget Price: N/A; Client Status: UNDER_REVIEW; Core Material: NON-MAGNETIC; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx?la=en-gb; Datasheet URL 1: http://psearch.murata.com/inductor/product/LQP03TN12NHZ2%23.pdf; Datasheet URL 2: http://www.murata.com/~/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 2.9GHz; Mass: 0.0002g; Max Oper Temp: +125DEGC; Max Tol: +3%; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +3%; Min Oper Temp: -55DEGC; Min Tol: -3%; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -3%; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06956; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06956; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Resistance: 0.7; Revision: R020; RoHS Status: ROHS_COMPLIANT; Rtd Current: 0.25A; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN12NHZ2J; Vendor Part Status: Active; Weight: 0.0002g
L37 = INDUCTOR: INDUCTOR, RF, CHIP, 3nH, -0.1nH/+0.1nH, 0.45A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-9101.pdf; Country of Origin: Missing Info; Datasheet URL: http://www.murata.com/en-eu/api/pdfdownloadapi?cate=cgInductors&partno=LQP03TN3N0BZ2%23; Frequency: 11900MHz; Mass: 0.0002g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-08394; PCB Package: 0201; Packing Size: 15000; Packing Type: Tape & Reel; Part Number: 03-08394; Part Type: Inductor|RF|CHIP|0201; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jul 08, 2021; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Rated Current: 0.45A; Resistance: 0.25; Revision: R005; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN3N0BZ2D; Vendor Part Status: Active
L38 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 2.5nH, -0.1nH/+0.1nH, 0.5A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-0015.pdf; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=97118; BU Name: DYNAMIC PRECISION GDANSK; Budget Currency: EUR; Budget Price: 0.03371; Client Status: UNDER_REVIEW; Core Material: NON-MAGNETIC; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx?la=en-gb; Datasheet URL 1: http://psearch.murata.com/inductor/product/LQP03TN2N5B02%23.pdf; Datasheet URL 2: http://www.murata.com/~/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 10GHz; Mass: 0.0002g; Max Oper Temp: +125DEGC; Max Tol: +0.1nH; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1nH; Min Oper Temp: -55DEGC; Min Tol: -0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06928; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06928; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Resistance: 0.2; Revision: R020; RoHS Status: ROHS_COMPLIANT; Rtd Current: 0.5A; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN2N5B02J; Vendor Part Status: Active; Weight: 0.0002g
L39 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 5.1nH, -3%/+3%, 0.35A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-9101.pdf; Country of Origin: Missing Info; Datasheet URL: http://www.murata.com/en-eu/api/pdfdownloadapi?cate=cgInductors&partno=LQP03TN5N1HZ2%23; Frequency: 4.2GHz; Mass: 0.0002g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +3%; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -3%; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06947; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06947; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Rated Current: 0.35A; Resistance: 0.4; Revision: R027; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN5N1HZ2J; Vendor Part Status: Active
L40 L45 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 10nH, -3%/+3%, 0.25A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-9101.pdf; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/emc/emifil/c51e.ashx?la=en&cvid=20220119013540000000; Frequency: 3.2GHz; Mass: 0.0002g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +3%; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -3%; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06954; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06954; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Rated Current: 0.25A; Resistance: 0.7; Revision: R025; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN10NHZ2J; Vendor Part Status: Active
L41 L44 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 3.4nH, -0.1nH/+0.1nH, 0.45A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-0015.pdf; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 7GHz; Mass: 0.0002g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06937; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06937; Part Type: Inductor|RF|CHIP|0201; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jun 27, 2018; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Rated Current: 0.45A; Resistance: 0.25; Revision: R026; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN3N4B02J; Vendor Part Status: Active
L42 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 22nH, -3%/+3%, 0.15A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-9101.pdf; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/emc/emifil/c51e.ashx?la=en&cvid=20220119013540000000; Frequency: 2.2GHz; Mass: 0.0002g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +3%; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -3%; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06962; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06962; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Rated Current: 0.15A; Resistance: 1.9; Revision: R025; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN22NHZ2J; Vendor Part Status: Active
R1 = RESISTOR: RESISTOR, THICK FILM, 100k, -5%/+5%, 0.063W, 50V, -55DEGC/+155DEGC, 0402, SMD; Additional Datasheet URL: N/A; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=114565; BU Name: TEXAS INSTRUMENTS NORWAY; Budget Currency: EUR; Budget Price: 0.014; Budgetary Price: 0.014 EUR; Client Status: UNDER_REVIEW; Country of Origin: United States; Datasheet URL: https://www.vishay.com/docs/20035/dcrcwe3.pdf; Datasheet URL 1: http://www.vishay.com/docs/20035/dcrcwe3.pdf; Datasheet URL 2: N/A; Definied Quality: INDUSTRIAL; Esd Level: N/A; Exclusive for Customers: TEXAS INSTRUMENTS NORWAY; Lead Time: 18; LifeCycle Status: ACTIVE; MPN: RESISTOR_0402_100k_+/-1%_50V_0.063W_M_+/-100PPM; MPN Status: ACTIVE; MSL: N/A; MTBF: N/A; MTBF Standard: N/A; Manufacturer: MANUFACTURER SELECTION; Mass: 0.00065g; Max Oper Temp: +155DEGC; Max TC: +200PPM/DEGC; Max Tol: +5%; Maximum Operating Temperature: +155DEGC; Maximum Temperature Coefficient: +200PPM/DEGC; Maximum Tolerance: +5%; Min Oper Temp: -55DEGC; Min TC: -200PPM/DEGC; Min Tol: -5%; Minimum Operating Temperature: -55DEGC; Minimum Temperature Coeficient: -200PPM/DEGC; Minimum Tolerance: -5%; Mounting Type: SMD; NOTE Status: PREFERRED; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=01-22492; Notes: Standard item: Duplicate Reason: custom footprint for TEXAS INSTRUMENTS NORWAY.; Old Footprint: RESC1005X40N; PCB Package: 0402; Packing Size: 10000; Packing Type: Tape & Reel; Part Number: 01-22492; Part Type: Resistor|0402|STANDARD; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jun 20, 2016; REACH/SVHC Source: Material Declaration; REACH/SVHC Status: Unaffected; REACH/SVHC_COMPLIANCE: COMPLIANT; REACH/SVHC_DETAILS: SVHC LIST VERSION Jun 20, 2016; REACH/SVHC_SOURCE: MATERIAL DECLARATION; REACH/SVHC_STATUS: UNAFFECTED; ROHS: Exempt; Rated Current: N/A; Rated Power: 0.063W; Rated Voltage: 50V; Resistor Type: THICK FILM; Revision: R021; RoHS Status: ROHS_COMPLIANT; Rtd Current: N/A; Rtd Power: 0.063W; Rtd Voltage: 50V; Status: Released; Texas Part Status: Under Review; Type: Resistor; Vendor: VISHAY; Vendor Part Number: CRCW0402100KJNED; Vendor Part Status: Active; Weight: 0.00065g
U2 = IC_RF_SKY13317-373LF_MLP8: IC, ANALOG, RF, SWITCH,  20MHz TO 6GHz, SP3T, VCONTROL:0V TO 5V, MLP8-EP, SMD; Additional Datasheet URL: https://www.skyworksinc.com/en/Products/switches/SKY13317-373LF; AutoDoc File: https://notefied-dynamic-precision.com/DB/Apps/Desktop/Item/Object.aspx?id=117700; BU Name: DYNAMIC PRECISION GDANSK; Budgetary Price: 0.844 EUR; CLASS: IO; Client Status: UNDER_REVIEW; Datasheet URL: https://www.skyworksinc.com/-/media/SkyWorks/Documents/Products/301-400/SKY13317_373LF_200914K.pdf; Datasheet URL 1: http://www.skyworksinc.com/uploads/documents/SKY13317_373LF_200914K.pdf; Datasheet URL 2: N/A; Frequency: 20MHz TO 6GHz; Mass: N/A; Max Oper Temp: +100DEGC; Maximum Operating Temperature: +100DEGC; Min Oper Temp: -40DEGC; Minimum Operating Temperature: -40DEGC; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=18-33966; PCB Package: MLP8-EP; Packing Size: N/A; Packing Type: Tape & Reel; Part Number: 18-33966; Part Type: IC|ANALOG|RF|SWITCH; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Dec 19, 2012; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Rated Voltage: 0V TO 5V; Revision: R016; RoHS Status: ROHS_COMPLIANT; Rtd Voltage: 0V TO 5V; Status: Released; Texas Part Status: Under Review; Type: IC; Vendor: SKYWORKS; Vendor Part Number: SKY13317-373LF; Vendor Part Status: Active
Y1 = XTAL: CRYSTAL, RESONATOR, 32.768kHz, -40DEGC/+125DEGC, SMD; ALT_SYMBOLS: XTAL_TZ3581F_A2L,XTAL_TZ3581F_A2M; Capacitance: 7pF; Datasheet URL: https://www.taisaw.com/en/product.php?pc=7; Maximum Operating Temperature: +125DEGC; Maximum Stability: N/A; Maximum Tolerance: +20PPM; Minimum Operating Temperature: -40DEGC; Minimum Stability: N/A; Minimum Tolerance: -20PPM; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=12-01571; Packing Size: 336; Packing Type: Tray; Part Number: 12-01571; Part Type: Crystal|RESONATOR; REACH/SVHC Compliance: Missing Info; REACH/SVHC Details: N/A; REACH/SVHC Source: N/A; REACH/SVHC Status: Missing Info; ROHS: Compliant; Revision: R001; Status: Released; Texas Part Status: Under Review; Type: Crystal; Vendor: TAI-SAW; Vendor Part Number: TZ3581F; Vendor Part Status: Active
Y2 = XTAL_4PINS_1_3: CRYSTAL, RESONATOR, 48MHz, -16PPM/+18PPM, -40DEGC/+105DEGC, SMD; ALT_SYMBOLS: OSCCC200X160X50-4A2L,OSCCC200X160X50-4A2M; Capacitance: 7pF; Datasheet URL: https://www.taisaw.com/en/product.php?pc=7; Mass: 0.0057g; Maximum Operating Temperature: +105DEGC; Maximum Stability: +18PPM; Maximum Tolerance: +5PPM; Minimum Operating Temperature: -40DEGC; Minimum Stability: -16PPM; Minimum Tolerance: -5PPM; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=12-01572; Packing Size: 3000; Packing Type: Tape & Reel; Part Number: 12-01572; Part Type: Crystal|RESONATOR; REACH/SVHC Compliance: Missing Info; REACH/SVHC Details: N/A; REACH/SVHC Source: N/A; REACH/SVHC Status: Missing Info; ROHS: Compliant; Revision: R001; Status: Released; Texas Part Status: Under Review; Type: Crystal; Vendor: TAI-SAW; Vendor Part Number: TZ3780AAAO44; Vendor Part Status: Active
Z1 = CAPACITOR: CAPACITOR, CERAMIC C0G/NP0, 2.5pF, 50V, -0.1pF/+0.1pF, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: CAPC0603X35B2L,CAPC0603X35B2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/GRM0335C1H2R5BA01-01A.pdf; Country of Origin: China,Japan; Datasheet URL: http://www.murata.com/en-eu/api/pdfdownloadapi?cate=luCeramicCapacitorsSMD&partno=GRM0335C1H2R5BA01%23; Dielectric Type: C0G/NP0; Mass: 0.00033g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1pF; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1pF; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=02-06139; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 02-06139; Part Type: Capacitor|CERAMIC|0201|STANDARD; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jul 7, 2017; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Rated Voltage: 50V; Revision: R032; Status: Released; Texas Part Status: Under Review; Type: Capacitor; Vendor: MURATA; Vendor Part Number: GRM0335C1H2R5BA01J; Vendor Part Status: Active
Z2 = CAPACITOR: CAPACITOR, CERAMIC C0G/NP0, 47pF, 50V, -5%/+5%, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: CAPC0603X35B2L,CAPC0603X35B2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/GRM0335C1H470JA01-01A.pdf; Budgetary Price: 0.0024 USD; Country of Origin: China,Japan,Philippines; Datasheet URL: http://www.murata.com/en-eu/api/pdfdownloadapi?cate=luCeramicCapacitorsSMD&partno=GRM0335C1H470JA01%23; Dielectric Type: C0G/NP0; Lead Time: 11; Mass: 0.00033g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +5%; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -5%; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=02-09159; PCB Package: 0201; Packing Size: 15000; Packing Type: Tape & Reel; Part Number: 02-09159; Part Type: Capacitor|CERAMIC|0201|STANDARD; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jun 27, 2018; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Rated Voltage: 50V; Revision: R016; Status: Released; Texas Part Status: Under Review; Type: Capacitor; Vendor: MURATA; Vendor Part Number: GRM0335C1H470JA01D; Vendor Part Status: Active
Z3 = CAPACITOR: CAPACITOR, CERAMIC C0G/NP0, 5.6pF, 50V, -0.1pF/+0.1pF, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: CAPC0603X35B2L,CAPC0603X35B2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/GRM0335C1H5R6BA01-01A.pdf; Budgetary Price: 0.00272 USD; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/capacitor/mlcc/c02e.ashx?la=en-gb; Dielectric Type: C0G/NP0; Lead Time: 11; Mass: 0.00033g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1pF; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1pF; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=02-06170; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 02-06170; Part Type: Capacitor|CERAMIC|0201|STANDARD; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jul 7, 2017; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Rated Voltage: 50V; Revision: R025; Status: Released; Texas Part Status: Under Review; Type: Capacitor; Vendor: MURATA; Vendor Part Number: GRM0335C1H5R6BA01J; Vendor Part Status: Active
Z7 = CAPACITOR: CAPACITOR, CERAMIC C0G/NP0, 3.9pF, 50V, -0.1pF/+0.1pF, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: CAPC0603X35B2L,CAPC0603X35B2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/A01X/G101/ENG/GRM0335C1H3R9BA01-01A.pdf; Budgetary Price: 0.00272 USD; Country of Origin: China,Japan,Philippines; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/capacitor/ceramiccapacitor/c02e.ashx; Dielectric Type: C0G/NP0; Lead Time: 11; Mass: 0.00033g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1pF; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1pF; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=02-06153; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 02-06153; Part Type: Capacitor|CERAMIC|0201|STANDARD; REACH/SVHC Compliance: Compliant; REACH/SVHC Details: SVHC List Version Jul 7, 2017; REACH/SVHC Source: REACH Declaration; REACH/SVHC Status: Unaffected; ROHS: Compliant; Rated Voltage: 50V; Revision: R030; Status: Released; Texas Part Status: Under Review; Type: Capacitor; Vendor: MURATA; Vendor Part Number: GRM0335C1H3R9BA01J; Vendor Part Status: Active
Z8 = INDUCTOR: INDUCTOR, RF, CHIP, NON-MAGNETIC CORE, 0.6nH, -0.1nH/+0.1nH, 0.85A, -55DEGC/+125DEGC, 0201, SMD; ALT_SYMBOLS: INDC0603X33A2L,INDC0603X33A2M; Additional Datasheet URL: https://search.murata.co.jp/Ceramy/image/img/P02/JELF243C-0015.pdf; Country of Origin: Missing Info; Datasheet URL: https://www.murata.com/-/media/webrenewal/support/library/catalog/products/inductor/chip/o05e.ashx; Frequency: 20GHz; Mass: 0.0002g; Maximum Operating Temperature: +125DEGC; Maximum Tolerance: +0.1nH; Minimum Operating Temperature: -55DEGC; Minimum Tolerance: -0.1nH; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=03-06909; PCB Package: 0201; Packing Size: 50000; Packing Type: Tape & Reel; Part Number: 03-06909; Part Type: Inductor|RF|CHIP|0201; ROHS: Compliant; Rated Current: 0.85A; Resistance: 0.07; Revision: R026; Status: Released; Texas Part Status: Under Review; Type: Inductor; Vendor: MURATA; Vendor Part Number: LQP03TN0N6B02J; Vendor Part Status: Active
U1 = IC_RF_CC1354P106T0RSK_VQFN64: IC, CUSTOM, TEXAS INSTRUMENTS, CC1354P106T0RSK, VQFN64-EP, SMD; ALT_SYMBOLS: QFNFC40P800X800X100-65A2L,QFNFC40P800X800X100-65A2M; Additional Datasheet URL: N/A; Datasheet URL: https://www.ti.com/; Exclusive for Customers: TEXAS INSTRUMENTS NORWAY; Mass: N/A; Maximum Operating Temperature: N/A; Minimum Operating Temperature: N/A; Mounting Type: SMD; NOTEfied URL: https://notefied-dynamic-precision.com/NOTEfiedWebInterface/part/show?partNumber=18-36708; Notes: Custom component.; PCB Package: VQFN64-EP; Packing Size: N/A; Packing Type: Missing Info; Part Number: 18-36708; Part Type: IC|CUSTOM; REACH/SVHC Details: SVHC List Version; ROHS: Missing Info; Revision: R001; Status: Released; Texas Part Status: Under Review; Type: IC; Vendor: TEXAS INSTRUMENTS; Vendor Part Status: Preliminary

## Nets
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C11.1 C12.1 C14.1 C15.1 C31.2 C33.1 C34.2 C35.2 C38.2 C50.2 C51.2 C52.2 C53.2 C54.2 C56.1 C59.2 C60.2 C61.2 CR1.1 J3.2 J3.3 J3.4 J3.5 L38.2 U1.65(EGP) U2.9(EGP) Y2.2(GND) Y2.4(GND) Z3.1 Z4.2 Z8.2 ; also on sheet 2 3 4
VDDR: C1.1 C7.1 C8.1 L1.1 U1.61(VDDR) U1.64(VDDR_RF)
VDDS: C2.1 C3.1 C4.1 C5.1 C6.1 C33.2 C34.1 FL1.1 L35.1 R1.2 U1.17(VDDS2) U1.30(VDDS3) U1.48(VDDS_DCDC) U1.60(VDDS)
DIO3_RF_PA: U2.3(V1) ; also on sheet 2
DIO34_RF_2G4: U2.7(V3) ; also on sheet 2
DIO35_RF_SUB1G: U2.6(V2) ; also on sheet 2
RX_TX: C11.2 C56.2 L12.1 L40.1 U1.7(RX_TX)
WMCU_RESET: C54.1 R1.1 U1.49(nRESET) ; also on sheet 2 3
WMCU_TCK: U1.33(JTAG_TCKC) ; also on sheet 2 3
WMCU_TMS: U1.32(JTAG_TSMC) ; also on sheet 2 3
WMCU_VDD: FL1.2 ; also on sheet 2 3
N3099875: C13.1 L11.1 L12.2 U1.1(2_4_GHZ_RF_P)
N3099951: C13.2 L13.2 L14.1
N3100073: C14.2 L14.2 L15.1
N3100081: C15.2 C16.1 L15.2
N3100105: C17.1 J3.1
N3100141: C12.2 L11.2 L13.1 U1.2(2_4_GHZ_RF_N)
N3100321: C17.2 C18.1 CR1.2 U2.1(RFC)
N3100543: C16.2 U2.8(RF3)
N3100575: C27.2 U2.5(RF2)
N3100757: L41.1 U1.3(SUB-1_GHZ_RF_P)
N3100925: L44.1 U1.4(SUB-1_GHZ_RF_N)
N3100985: L31.1 U1.5(TX_20DBM_P)
N3100993: C18.2 Z1.1
N3100997: L32.1 U1.6(TX_20DBM_N)
N3101199: C50.1 U1.8(X32K_Q1) Y1.1
N3101207: C51.1 U1.9(X32K_Q2) Y1.2
N3101223: C52.1 U1.63(X48M_P) Y2.1
N3101377: Z1.2 Z2.1 Z3.2 Z4.1
N3101433: A1.1 Z2.2
N3101449: C53.1 U1.62(X48M_N) Y2.3
N3101777: C32.1 L31.2 L34.1 L35.2
N3101817: C32.2 C35.1 C36.1 L36.2 L37.1
N3101861: C36.2 C37.1 L37.2 L39.1
N3101937: C38.1 C39.1 L39.2
N3101953: C39.2 U2.4(RF1)
N3101989: C31.1 L32.2 L34.2 L36.1
N3254079: L1.2 U1.47(DCDC_SW)
N3268642: C37.2 L38.1
N3281348: C9.1 U1.31(DCOUPL)
N3492676: C27.1 L27.2 Z7.1
N3492704: Z7.2 Z8.1
N3493209: C57.1 C58.1 L40.2 L41.2 L42.1
N3493257: C57.2 C59.1 L43.1 L45.2
N3493329: C60.1 L27.1 L43.2
N3493341: C58.2 C61.1 L42.2 L44.2 L45.1

Not connected (* = marked no-connect by the designer): U2 2(NC)*

## Notes on the sheets
sheet 1
- Wireless MCU RF
- Wireless MCU IO block placed on page 2
- 5 dBm 2.4 GHz
- RF Control Truth Table
- DIO3  DIO34  DIO35
  Shutdown   0     0      0
  Sub 1 GHz  0     0      1
  2.4 GHz    0     1      0
  20dBm PA   1     0      0
- Wireless MCU IO
  section on page 2
- Pin 17
- Pin 30
- Pin 60
- Pin 61
- Pin 64
- Optimised for 868/915
  MHz dual-band match.
  See App Note SWRA640
  for more information
  on optimised 868 MHz
  and 915 MHz single
  band matching networks
- 20 dBm 868-915 MHz
- Z1-Z4 for
  antenna matching
